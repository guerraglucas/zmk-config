## boards/arm/eyelash_nano/Kconfig.board
```kconfig
config BOARD_EYELASH_NANO
    bool "Eyelash Nano"
    depends on SOC_NRF52840_QIAA
```
